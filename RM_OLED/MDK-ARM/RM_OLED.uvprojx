# Keil uVision project RM_OLED.uvprojx, settings and files
target RM_OLED (ARM-ADS)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: RM_OLED
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c gpio.c spi.c main.c adc.c stm32f4xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_gpio.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_adc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c
  group bsp
    ../BSP/: oled.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f4xx.c
software components: CMSIS:CORE 4.1.0
